Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [COBie2.4DesignDeliverable], RevitIdentifiers [VersionGUID: 5ac5f04c-b170-4d08-b5f8-0b8c8be394cf, NumberOfSaves: 1]
File name: 0001
Time: 2024-09-05T14:22:06+01:00
Written by: ODA SDAI 23.12
Made in: Autodesk Revit 24.0.20.20 (ENU) - IFC 24.0.20.20

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Pset_ProductRequirements - Category: Project Information

# IfcBuildingElementProxy: 11791540_USA_HR1724-3LP_EDST-CLS:25172482_USA_11791540_HR1724-3LP_EDST-CLS, (2)
In: Default
Type - Material: z_Miele_Design_CLST, z_Miele_Design_Glass Black, z_Miele_Design_Cast, <Unnamed>, z_Miele_Connection_Gas, z_Miele_Connection_Electric, z_Miele_Design_Steel_Chrom
Type - Pset_ProductRequirements - Category: Specialty Equipment
Type - Pset_ProvisionForVoid - Width: 762 mm; Height: 980 mm; Depth: 702 mm
Classification: E1090320 Uniformat (Uniformat)
Pset_BuildingElementProxyCommon - Reference: 25172482_USA_11791540_HR1724-3LP_EDST-CLS; sets with these values: 2

# IfcDistributionPort, Port_360021_1
Description: Flow; FlowDirection: SOURCEANDSINK
